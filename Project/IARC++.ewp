# IAR project IARC++.ewp, settings and files
configuration TimerExample (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZG ST STM32F103ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL
  ICCARM.CCDiagSuppress: Pa050,Pe188,Pe546
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: IARC++.srec
  ILINK.IlinkOutputFile: cpp_timer.out
  ILINK.IlinkIcfFile: STM32F103xxG_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ADCExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG; ..\Drivers\ST\ADC; ..\Drivers\ST\PWR
configuration PWMExample (ARM, debug)
  as the first configuration, except:
configuration BKPExample (ARM, debug)
  as the first configuration, except:
configuration CRCExample (ARM, debug)
  as the first configuration, except:
configuration GPIOExample (ARM, debug)
  as the first configuration, except:
configuration IWDGExample (ARM, debug)
  as the first configuration, except:
configuration RTCExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG; ..\Drivers\ST\RTC
configuration SPIExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG; ..\Drivers\ST\SPI
configuration UARTExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG; ..\Drivers\ST\ADC
  ICCARM.CCOptStrategy: 2
configuration PWRExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
configuration DACExample (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\src; ..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc; ..\API; ..\APP; ..\Drivers; ..\Drivers\ST\GPIO; ..\Drivers\ST\Interrupts; ..\Drivers\ST\Timer; ..\Drivers\ST\UART; ..\Drivers\ST\BKP; ..\Drivers\ST\CRC; ..\Drivers\ST\IWDG; ..\Drivers\ST\ADC; ..\Drivers\ST\PWR; ..\Drivers\ST\DAC
  group 3rdParty
    ../3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_xl.s
  group 3rdParty/CMSIS
    ../3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group 3rdParty/STM32F10x_StdPeriph_Driver/inc
    ../3rdParty/ST/STM32F10x_StdPeriph_Driver/inc/: cortexm3_macro.h misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group 3rdParty/STM32F10x_StdPeriph_Driver/src
    ../3rdParty/ST/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group API
    ../API/: api_system_startup.cpp api_system_startup.h
  group APP
    ../APP/: adc_main.cpp bkp_main.cpp crc_main.cpp dac_main.cpp gpio_main.cpp iwdg_main.cpp pwr_example.cpp rtc_main.cpp spi_main.cpp timer_main.cpp timer_main_pwm.cpp uart_main.cpp
  group Drivers/ST/ADC
    ../Drivers/ST/ADC/: adc.cpp adc.h
  group Drivers/ST/BKP
    ../Drivers/ST/BKP/: bkp.cpp bkp.h
  group Drivers/ST/CRC
    ../Drivers/ST/CRC/: crc.cpp crc.h
  group Drivers/ST/DAC
    ../Drivers/ST/DAC/: dac.cpp dac.h
  group Drivers/ST/GPIO
    ../Drivers/ST/GPIO/: gpio.cpp gpio.h
  group Drivers/ST/Interrupts
    ../Drivers/ST/Interrupts/: stm32f10x_it.c stm32f10x_it.h
  group Drivers/ST/IWDG
    ../Drivers/ST/IWDG/: iwdg.cpp iwdg.h
  group Drivers/ST/PWR
    ../Drivers/ST/PWR/: pwr.cpp pwr.h
  group Drivers/ST/RTC
    ../Drivers/ST/RTC/: rtc.cpp rtc.h
  group Drivers/ST/SPI
    ../Drivers/ST/SPI/: spi.cpp spi.h
  group Drivers/ST/Timer
    ../Drivers/ST/Timer/: timer.cpp timer.h
  group Drivers/ST/UART
    ../Drivers/ST/UART/: print.cpp print.h uart.cpp uart.h
